IMAGE_INSTALL_append = " netscript "
IMAGE_INSTALL_append = " apps "
